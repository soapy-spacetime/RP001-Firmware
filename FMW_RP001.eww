<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\STM8L15x-16x-05x-AL31-L_StdPeriph_Lib\Project\FMW_RP001\EWSTM8\project.ewp</path>
    </project>
    <batchBuild />
</workspace>
